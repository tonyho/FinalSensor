# Keil uVision project FinalSensor.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: FinalSensor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: main.c 18B20.c DS1302DY.c LCD1602YT.c key44y.c UartPrintf.c
